require kodi-17.x.inc

COMPATIBLE_MACHINE = "^(vuuno4k)$"

EXTRA_OECONF += " --with-platform=vuplus-arm "

