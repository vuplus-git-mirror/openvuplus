require kodi-17.x.inc

COMPATIBLE_MACHINE = "^(vuduo4kse)$"

EXTRA_OECONF += " --with-platform=vuplus-arm "

