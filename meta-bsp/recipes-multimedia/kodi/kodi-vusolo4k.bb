require kodi-17.x.inc

COMPATIBLE_MACHINE = "^(vusolo4k)$"

EXTRA_OECONF += " --with-platform=vuplus-arm "

