require bluetoothsetup.inc

COMPATIBLE_MACHINE = "^(vuuno4kse)$"

SRCDATE = "20171114"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "c998bb74f6b9bdbc10db1184c9661133"
SRC_URI[sha256sum] = "506752bef0531a27d60273a5da1e45cd8f42e64f6ba65298911f2db05eec360c"

SRCDATE_PY3 = "20200812"
SRCDATE_PY3_PR = "r0"

SRC_URI[py3.md5sum] = "024ddd739bfc42124bb820bb9bbb6120"
SRC_URI[py3.sha256sum] = "4a121859f5fa8a660b87020654748c10d648668e2b3cd86afea0203cf57295b5"
