require bluetoothsetup.inc

COMPATIBLE_MACHINE = "^(vuuno4k)$"

SRCDATE = "20171114"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "c23fd4be1e20b6b351ba4d6f307b3550"
SRC_URI[sha256sum] = "fa4a8fb755013fe0d2a0e575ae1442bbf2de9d57bafb0d4919ab6ac60cc160dc"

SRCDATE_PY3 = "20200812"
SRCDATE_PY3_PR = "r0"

SRC_URI[py3.md5sum] = "69ca604d5dad9a3d7e88dbf08e03db54"
SRC_URI[py3.sha256sum] = "38ef0f7b3723c9b8ee7a922bb9150c35b3c488e7fb54a240a405e42c2b8152b6"
