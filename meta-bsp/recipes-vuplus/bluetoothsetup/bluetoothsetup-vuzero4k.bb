require bluetoothsetup.inc

COMPATIBLE_MACHINE = "^(vuzero4k)$"

SRCDATE = "20171114"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "462f37c6852b57d88a81b0cb1497acd5"
SRC_URI[sha256sum] = "f924e70ea45fbdd006523fd3bf5cdae50894039d9c1d95ecac8a5591d32ef6ad"

SRCDATE_PY3 = "20200812"
SRCDATE_PY3_PR = "r0"

SRC_URI[py3.md5sum] = "811b9ddfd2b00d5a71ffdfae207baed1"
SRC_URI[py3.sha256sum] = "e73a3c3865a8405bb5c3e56e07909b1cf7d8ba2a08690ff20770445c46676a9c"
