require bluetoothsetup.inc

COMPATIBLE_MACHINE = "^(vuultimo4k)$"

SRCDATE = "20171115"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "c4b6f4fd4040607b3b0c7f9456b284cf"
SRC_URI[sha256sum] = "b92599a981297a301d0c17de3acdeb68aec5677f017d515ca43c1f577f882142"

SRCDATE_PY3 = "20200812"
SRCDATE_PY3_PR = "r5"

SRC_URI[py3.md5sum] = "c2b450e62f96641f7fda693101beb2f3"
SRC_URI[py3.sha256sum] = "8c7e1f9e09a2a8a7d4809d2e94c99d49a893028f5fbc7679c4bfdf02942b3b27"

