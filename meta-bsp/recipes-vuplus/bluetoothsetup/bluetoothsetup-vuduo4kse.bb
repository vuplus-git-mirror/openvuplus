require bluetoothsetup.inc

COMPATIBLE_MACHINE = "^(vuduo4kse)$"

SRCDATE = "20200320"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "ee90c784d3a0b050e66ee81624fcb631"
SRC_URI[sha256sum] = "e079638b1ff6d5d1cbea86ec336eb85ff2e33e1cacd6e1acac97520b8568ecd7"

SRCDATE_PY3 = "20200909"
SRCDATE_PY3_PR = "r0"

SRC_URI[py3.md5sum] = "29f025fa91f4759bc9be29148339e2de"
SRC_URI[py3.sha256sum] = "23146d570ba16b422b3ae199289084e55cc5e00d1e812a741837132133453402"
