require bluetoothsetup.inc

COMPATIBLE_MACHINE = "^(vuduo4k)$"

SRCDATE = "20181109"
SRCDATE_PR = "r1"

SRC_URI[md5sum] = "e361db36f21cf1d5a17cc82d720510e2"
SRC_URI[sha256sum] = "2a6c7687f470210f69758fed6240f8b99728a78e4a9283f47c8c57495ee39fb7"

SRCDATE_PY3 = "20200812"
SRCDATE_PY3_PR = "r0"

SRC_URI[py3.md5sum] = "e94e91d562f4da88a3ab535cb7f982de"
SRC_URI[py3.sha256sum] = "e138db70b21a9d73672cae0a91fca397112c1159ea6c0f488d2d51699c17a4e9"
