require vuplus-manual.inc

COMPATIBLE_MACHINE = "^(vuzero4k)$"

SRC_DATE = "20171123_p0"

SRC_URI[md5sum] = "d7f3bc69a558231d2f79f06415354cb3"
SRC_URI[sha256sum] = "a6c63706a6d01f6f3051d8397b18b327e5410c6084dc3ad66ff62516b01309ae"

