require vuplus-manual.inc

COMPATIBLE_MACHINE = "^(vuduo4kse)$"

SRC_DATE = "20200918_p0"

SRC_URI[md5sum] = "823d6d47f1139a85fb287af6840274e7"
SRC_URI[sha256sum] = "9f35f3d2c6e5adde293b070002067c7d23483769d700dd1dc700860edd46b067"
