require vuplus-manual.inc

COMPATIBLE_MACHINE = "^(vuduo4k)$"

SRC_DATE = "20181102_p0"

SRC_URI[md5sum] = "b18e78380b34cc14966cac5ffd6cfd6c"
SRC_URI[sha256sum] = "d6d0836452bbd76615f6407ac82d0935ec1f9ee69642b4c23b1ed70e5929021d"

