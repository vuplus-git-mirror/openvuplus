require vuplus-manual.inc

COMPATIBLE_MACHINE = "^(vuuno4kse)$"

SRC_DATE = "20171016_p0"

SRC_URI[md5sum] = "8e3ddd2852a3ff01fca7203517141bac"
SRC_URI[sha256sum] = "702cb0a8eb144b78702d7e469dcbba1f74bf4966ec0ea35e496155208aa99080"

