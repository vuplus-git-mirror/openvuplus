require vuplus-platform-util.inc

COMPATIBLE_MACHINE = "^(vuzero4k)$"

PV="17.1"
SRCDATE = "20171124"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "07031eaed52fdcf66dcd183a6f254057"
SRC_URI[sha256sum] = "6340cee91e6875535f026282539db1390bb13626291a8aa8f8f0109da992671f"
