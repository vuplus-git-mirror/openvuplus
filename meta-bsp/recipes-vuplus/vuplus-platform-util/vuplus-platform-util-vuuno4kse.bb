require vuplus-platform-util.inc

COMPATIBLE_MACHINE = "^(vuuno4kse)$"

PV="16.1"
SRCDATE = "20171116"
SRCDATE_PR = "r0"


SRC_URI[md5sum] = "40bcabcbda6f9e2bf1e5320b087b2c64"
SRC_URI[sha256sum] = "c8220ca6ec77a69571d269477afc06fdae845aaeaf473419ebf819a8d421a245"
