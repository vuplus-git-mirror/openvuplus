require vuplus-dvb-modules.inc

COMPATIBLE_MACHINE = "^(vusolose)$"

SRCDATE = "20171204"

MODULES_NAME = "procmk\ndvb-bcm7241\nbrcmfb\nfpga_directc"

SRC_URI[md5sum] = "41a7ef206140e8e7a1222ded8e8a9046"
SRC_URI[sha256sum] = "93daf5c8b44cf8fcf315c7dc2441377190fc8a6670e2ee67a5ee8a0e12afaa6e"
