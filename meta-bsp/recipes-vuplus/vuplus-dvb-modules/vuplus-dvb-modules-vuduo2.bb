require vuplus-dvb-modules.inc

COMPATIBLE_MACHINE = "^(vuduo2)$"

SRCDATE = "20171204"

MODULES_NAME = "procmk\ndvb-bcm7424\nbrcmfb\nfpga_directc"

SRC_URI[md5sum] = "33dc73fe854cce2e09e8f9d1266411d3"
SRC_URI[sha256sum] = "f03229040a872eeeac906ddd6c4f89d56a1584c8e258a49b075f9b571489e5aa"
