require vuplus-dvb-modules.inc

COMPATIBLE_MACHINE = "^(vuuno)$"

SRCDATE = "20171127"

MODULES_NAME = "procmk\ndvb-bcm7413\nbrcmfb\nfpga_directc"

SRC_URI[md5sum] = "bf572787685fbe36d9bcb62ecd12c340"
SRC_URI[sha256sum] = "9088011002453c6c4daf2f55474cc284d6e776bf7f5f6dbf51e8f309b615f88b"
