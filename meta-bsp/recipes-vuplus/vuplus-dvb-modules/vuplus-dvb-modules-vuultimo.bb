require vuplus-dvb-modules.inc

COMPATIBLE_MACHINE = "^(vuultimo)$"

SRCDATE = "20171204"

MODULES_NAME = "procmk\ndvb-bcm7413\nbrcmfb\nfpga_directc"

SRC_URI[md5sum] = "e32edeaf689027e8b71dfc5d9344c09a"
SRC_URI[sha256sum] = "519ad60584199ce079099470a16f64f7b0b4eba310a827e87ff83d5e50c1a254"
