require vuplus-dvb-modules.inc

COMPATIBLE_MACHINE = "^(vusolo2)$"

SRCDATE = "20171107"

MODULES_NAME = "procmk\ndvb-bcm7356\nbrcmfb\nfpga_directc"

SRC_URI[md5sum] = "e1c4d3b99c3a765a704a1717b5478810"
SRC_URI[sha256sum] = "cf0606f09e2651dd9472abf48f7230d0daffa1ed0d72716fd81730aeda44b5c9"
