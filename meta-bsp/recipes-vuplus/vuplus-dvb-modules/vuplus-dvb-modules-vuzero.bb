require vuplus-dvb-modules.inc

COMPATIBLE_MACHINE = "^(vuzero)$"

SRCDATE = "20170822"

MODULES_NAME = "procmk\ndvb-bcm7362\nbrcmfb\nfpga_directc"

SRC_URI[md5sum] = "184a29457017700b0ec4340350af1127"
SRC_URI[sha256sum] = "9f48baaa8ad8ebe732de17e4504a62e26aa031570bf2fe3328b9276de71f76fe"
