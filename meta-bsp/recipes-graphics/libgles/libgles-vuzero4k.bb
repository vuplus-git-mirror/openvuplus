require libgles.inc

COMPATIBLE_MACHINE = "^(vuzero4k)$"

SRCDATE = "20171124"
SRCDATE_PR = "r0"
PV="17.1"

SRC_URI[md5sum] = "2dc895f19559330ef01f0661889be09f"
SRC_URI[sha256sum] = "45293d8cf61154b96a97b0eadeee9e3f3ee9d33db19a4c4673feef873175f83e"
