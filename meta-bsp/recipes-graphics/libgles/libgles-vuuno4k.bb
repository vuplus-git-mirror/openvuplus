require libgles.inc

COMPATIBLE_MACHINE = "^(vuuno4k)$"

SRCDATE = "20170522"
SRCDATE_PR = "r0"
PV="16.1"

S = "${WORKDIR}/libgles-vuuno4k"

SRC_URI[md5sum] = "68026a2d00ef251c0c6663abf1fc25e9"
SRC_URI[sha256sum] = "d7341b873bd451a7fc17a8389773afcb659daac0334587e5bd812fe5f1b84e20"
