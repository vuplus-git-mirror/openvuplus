require libgles.inc

COMPATIBLE_MACHINE = "^(vuduo4k)$"

SRCDATE = "20181116"
SRCDATE_PR = "r0"
PV="18.1"

S = "${WORKDIR}/libgles-vuduo4k"

SRC_URI[md5sum] = "6e21dcbc17d78e2a8e06cd4144430126"
SRC_URI[sha256sum] = "dbc2de8261e42977e95b5719effffb44c882b9f2e470caf79e7723f4b9b1a438"
