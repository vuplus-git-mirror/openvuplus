require libgles.inc

COMPATIBLE_MACHINE = "^(vuultimo4k)$"

SRCDATE = "20180208"
SRCDATE_PR = "r0"
PV="17.1"

S = "${WORKDIR}/libgles-vuultimo4k"

SRC_URI[md5sum] = "2bcd4ef283e7bc4ceb2aac1d06b1ef29"
SRC_URI[sha256sum] = "9d0cafbb8e08d08fc969d97183838547b5521e5507bc04637fe21f77a183a3d4"
