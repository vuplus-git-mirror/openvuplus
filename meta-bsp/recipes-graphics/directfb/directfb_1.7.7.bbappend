FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-${PV}:"

require directfb-${PACKAGE_ARCH}_1.7.7.inc

